# Keil uVision project IAP.uvproj, settings and files
target IAP (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IAP +hex
  AfterMake: fromelf.exe --bin -o OBJ/@p.bin OBJ/@p.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\USER;.\FATFS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ./CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group STM32F103x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_can.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c common.c ymodem.c download.c upload.c sram.c ili93xx.c sys.c rtc.c can.c
  group FatFS
    ./FATFS/: File_Config.c NAND_STM32F1xx.c Retarget.c FS_CM3.lib
